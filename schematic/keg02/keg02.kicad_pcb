# Repository ondrejh/keg_scale

## KiCad design schematic/keg02/keg02.kicad_pcb

Parts:
C1, C8: 220u / 10V; CP_Elec_6.3x7.7
C3, C6, C10, C11, C12, C14, C16: 4u7; C_1206
C4, C5, C9, C13, C17, C18: 100n; C_0603
D1: B5819W; D_SOD-123
FB1, FB2, FB3, FB4: Ferrite_Bead_Small; R_0805
IC1: ESP-12E; ESP-12E_SMD
IC3: AP2112K-3.3; SOT-23-5
P1, P6: Conn_01x04; DISP_CONN
P2: Conn_01x03; LC_CONN
P5: Conn_01x02; PWR_CONN
R1, R2, R3, R5, R6, R7: 10k; R_0603
R4: NA; R_0603
R8, R9, R10, R11, R12: 100; R_0603
R13: 4k7; R_0603
X1: NA; PROG_CON

Connections:
+3V3: C8.1, C9.1, C10.1, C11.1, FB1.2, FB2.2, FB3.2, FB4.2, IC3.5, R2.1, R4.1, R6.1
/PWDISP: C16.1, C17.1, FB3.1, P6.2, R5.1
/PWIC1: C3.1, C4.1, FB1.1, IC1.8 (VCC), R1.1
/PWIC2: C12.1, C13.1, FB2.1, P1.4
/PWIC3: C14.1, C18.1, FB4.1, P2.3, R13.1
/PWIN: D1.2 (A), P5.2
/PWIN2: C1.1, C5.1, C6.1, D1.1 (K), IC3.1, R3.2
DISP_SCL: IC1.14 (GPIO5), R11.2
DISP_SDA: IC1.13 (GPIO4), R10.2
GND: C1.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C16.2, C17.2, C18.2, IC1.9 (GND), IC3.2, P1.1, P2.1, P5.1, P6.1, R7.2, X1.1
GPIO0: IC1.12 (GPIO0), R6.2, X1.4
LOADCELL_DOUT: IC1.5 (GPIO14), R8.2
LOADCELL_SCK: IC1.6 (GPIO12), R9.2
unnamed: IC1.3 (CH_PD), R1.2
unnamed: IC1.10 (GPIO15), R7.1
unnamed: IC1.11 (GPIO2), R5.2
unnamed: IC3.3, R3.1
unnamed: P1.2, R9.1
unnamed: P1.3, R8.1
unnamed: P2.2, R12.1, R13.2
unnamed: P6.3, R11.1
unnamed: P6.4, R10.1
unnamed: R4.2, X1.2
RST: IC1.1 (REST), R2.2, X1.3
RXD: IC1.15 (RXD), X1.5
TEMP: IC1.7 (GPIO13), R12.2
TXD: IC1.16 (TXD), X1.6

Notes on the sheet:
TXD RXD GPIO0 RST 3V3 GND
SDA SCK VCC GND
V+ GND
VCC DO / RX CK / TX GND
VCC DQ GND

Board: 2 copper layers, 50.8 x 25.4 mm, 40 parts (2 on the bottom side), 27 nets.

## KiCad design schematic/splitter/splitter.kicad_pcb

Board: 2 copper layers, 22.2 x 15.9 mm, 5 parts (0 on the bottom side), 8 nets.

Parts:
P1, P2, P3, P4: Conn_01x03; LC_CONN
P5: Conn_01x04; DISP_CONN

Connections:
/A+: P4.2, P5.2
/A-: P2.2, P5.3
/BL1: P2.3, P3.1
/BL2: P1.1, P4.3
/E+: P1.2, P5.4
/E-: P3.2, P5.1
/WH1: P1.3, P2.1
/WH2: P3.3, P4.1

## Commit log

2020-05-04 initial commit - display and scale works
2020-05-05 initial github commit
2020-05-05 wifi ap
2020-05-05 microdns
2020-05-07 webi
2020-05-08 webi placeholder
2020-05-08 improved webi
2020-05-08 webi automatic export
2020-05-08 todo update
2020-05-08 debug: webi lineends
2020-05-08 ajax: timeout, and fail handling
2020-05-08 calibration in put (webi) and data output (sketch)
2020-05-08 calibration table output
2020-05-08 callibration value add, change
2020-05-08 refactorise (function prototypes)
2020-05-08 minor
2020-05-08 add and delete calibrations
2020-05-08 eeprom doesnt work
2020-05-08 eeprom calibration storage
2020-05-08 new todo list
2020-05-08 tab structure
2020-05-09 interpolate
2020-05-09 show measurement in units
2020-05-09 local files for testing
2020-05-09 ignore list
2020-05-09 webi.h update
2020-05-10 generic eerpom save/load
2020-05-10 unit name
2020-05-10 data.json updated, live update script
2020-05-10 webi: primary unit
2020-05-10 display primary units
2020-05-10 webi: primary unit (2nd attempt)
2020-05-10 calibration page
2020-05-11 callibration page
2020-05-12 webi update
2020-05-12 temperature sensor
2020-05-12 keg - basic response
2020-05-13 longterm stability measureement
2020-05-13 make chart from measurement
2020-05-13 special folder for diagnostics
2020-05-13 sensor holder
2020-05-13 error measurement (glued sensor)
2020-05-13 exec
2020-05-13 keg iface
2020-05-13 webi data
2020-05-14 new measurement data
2020-05-14 keg name
2020-05-14 new measurement
2020-05-15 webi by TB
2020-05-16 nice webi
2020-05-16 display secondary units, save keg
2020-12-24 net setup page
2020-12-24 keg simulator
2020-12-25 simulation improved
2020-12-25 improved hiding
2020-12-25 simulation - keep calibration
2020-12-25 raw is int (not float)
2020-12-25 one button, no hiding
2020-12-25 keg start improved
2020-12-27 config and simulation
2020-12-27 obsolete
2020-12-27 new keg-start form and simulation using post
2020-12-28 config using post
2020-12-28 not used anymore
2020-12-28 calibration add value using post (backend)
2020-12-28 add calib using do.php and post
2020-12-30 load cell test sketch
2020-12-30 v01 sketch archive
2020-12-30 barell svg
2020-12-30 icon management
2020-12-30 calibration can be forced
2020-12-30 cleaning
2020-12-31 calibration save and restore script
2020-12-31 sw version
2021-01-01 save config in eeprom
2021-01-03 new keg and finish keg simulatin using json data
2021-01-03 last export
2021-01-03 specific device calibration
2021-01-03 more precise callibration
2021-01-04 hw v01 - schematic and basic layout (need routing)
2021-01-05 hx711 module model
2021-01-05 layout
2021-01-05 programmer tag schematic
2021-01-06 programing connector layout
2021-01-06 programming connector gerber
2021-01-06 pogo pin model
2021-01-06 lib needed for previous commits
2021-01-06 keg01 gerber
2021-01-06 doc images
2021-01-06 project cleaup
2021-01-07 panelizing markers and adjustment
2021-01-07 voltage follower for gauge display
2021-01-07 3d model
2021-01-07 gauge sketch (testing gauge)
2021-01-07 gauge jogging
2021-01-08 up / down test
2021-01-08 gauge and backlight utils
2021-01-08 clean
2021-01-08 improves
2021-01-09 display
2021-01-16 gauge setup mode
2021-02-11 different device
2021-02-19 models
2021-03-04 different kegscale
2021-03-04 baldas artwork
2021-03-19 large file removed
2021-03-22 new gauge version
2021-03-22 new artwork implemented
2021-03-22 gauge booster output
2021-03-22 gauge prototype
2021-03-25 2nd version of hw
2021-03-25 gerber data and bom
2021-03-25 splitter pcb
2021-03-25 splitter gerber
2021-03-25 dimensions
2021-04-04 new scale
2021-04-04 new webi by t.balda
2021-04-07 keg02 rendered image (doc)
2021-05-19 ibom
2021-05-19 3d models
2021-05-19 large scale model
2021-05-21 model update
2021-05-22 model plus teplomer
2021-05-23 small base model
2021-05-28 pairing
2021-06-29 plus line
2021-06-29 FCADEB calibration data
2021-06-29 trying to implement keg2_v2
2021-06-29 its whisplering!
2021-06-29 version doc string
2021-06-30 try html, back to bin (because of escape sequences)
2021-06-30 save list of kegs to eeprom
2021-06-30 rename keg list
2021-06-30 remove template
2021-07-02 new scale, new calibration file
2021-10-14 let matrix test app
2021-10-14 who knows
2021-10-14 color picker
2021-10-14 rescue lib
2021-10-14 esp matrix driver
2021-10-14 curl matrix drive
2021-10-17 more editing
2021-10-17 new ip
2021-10-17 allways clear matrix at the begining
2021-10-31 bom update
2021-11-08 ds18 temp
2021-11-08 small plate
2021-11-08 drawings (small)
2021-11-24 no AP - connect to local wifi
2021-11-25 more display info (network and temperature)
2021-11-25 local network can be set
2021-12-13 calibration list
2021-12-21 no-cache
2021-12-30 recent callibration data
2021-12-30 directory roshade, improve webi export
2022-01-01 gauge setup webi
2022-01-01 setup page gets data from json
2022-01-02 gauge iface test script
2022-01-11 read data from scale and save it to file
2022-01-17 new hw test
2022-01-17 http server, display temperature
2022-01-24 json output
2022-01-31 api barebasics
2022-02-01 some eesave, but not fineshed
2025-12-19 no jquerry webi - ai converted
2025-12-19 v0.5 no jquerry (lighter webi)
2025-12-19 mqtt settings, firs connection (json)
2025-12-20 mqtt alpha version
